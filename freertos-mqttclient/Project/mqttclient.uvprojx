# Keil uVision project mqttclient.uvprojx, settings and files
target LwIP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mqttclient +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\usart;..\User\led;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\LwIP\include;..\LwIP\include\compat;..\LwIP\include\lwip;..\LwIP\include\netif;..\LwIP\include\lwip\apps;..\LwIP\include\lwip\priv;..\LwIP\include\lwip\prot;..\User\arch;..\User\cm_backtrace;..\mqttclient\common;..\mqttclient\common\log;..\mqttclient\network;..\mqttclient\network\mbedtls\include;..\mqttclient\network\mbedtls\wrapper;..\mqttclient\network\mbedtls\include\mbedtls;..\mqttclient\mqtt;..\mqttclient\mqttclient;..\mqttclient\platform\FreeRTOS;..\mqttclient\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DOC
    ../Doc/: readme.txt
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
  group USER
    ../User/: main.c stm32f4xx_it.c board.c
    ../User/usart/: bsp_debug_usart.c
    ../User/led/: bsp_led.c
    ../User/sdram/: bsp_sdram.c
    ../User/eth/: bsp_eth.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group LwIP/api
    ../LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../LwIP/netif/: ethernet.c bridgeif.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group LwIP/arch
    ../User/arch/: ethernetif.c sys_arch.c
  group cm_backtrace
    ../User/cm_backtrace/: cm_backtrace.c
    ../User/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group mqttclient
    ../mqttclient/mqttclient/: mqtt_defconfig.h mqttclient.c mqttclient.h
    ../mqttclient/test/: mqtt_config.h
  group mqttclient/log
    ../mqttclient/common/log/: fifo.c format.c salof.c
    ../mqttclient/common/log/arch/freertos/: arch.c
  group mqttclient/lib
    ../mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/network
    ../mqttclient/network/: network.c nettype_tls.c nettype_tcp.c
  group mqttclient/platform
    ../mqttclient/platform/FreeRTOS/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group mqttclient/common
    ../mqttclient/common/: random.c random.h mqtt_error.h mqtt_list.c mqtt_list.h mqtt_log.h
  group mqttclient/tls
    ../mqttclient/network/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../mqttclient/network/mbedtls/wrapper/: entropy_hardware_alt.c net_sockets_alt.c timing_alt.c
